# Keil uVision project experimental_ble_app_blinky_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: .\app;.\ble_common;.\ble_driver;.\ble_lib;.\ble_services;.\bsp;.\segger_rtt;.\soft_device;.\ble_driver\common;.\ble_driver\config;.\ble_driver\delay;.\ble_driver\gpiote;.\ble_driver\hal;.\ble_driver\uart;.\ble_lib\fifo;.\ble_lib\timer;.\ble_lib\uart;.\ble_lib\util;.\ble_services\ble_lbs;.\soft_device\s132\headers;.\ble_lib\button
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ./app/: main.c
  group Board Support
    ./bsp/: bsp.c
  group nRF_BLE
    ./ble_common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ./ble_services/ble_lbs/: ble_lbs.c
  group nRF_Drivers
    ./ble_driver/uart/: nrf_drv_uart.c
    ./ble_driver/delay/: nrf_delay.c
    ./ble_driver/common/: nrf_drv_common.c
    ./ble_driver/gpiote/: nrf_drv_gpiote.c
    ./ble_lib/uart/: app_uart_fifo.c
  group nRF_Libraries
    ./ble_lib/button/: app_button.c
    ./ble_lib/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ./ble_lib/fifo/: app_fifo.c
    ./ble_lib/timer/: app_timer.c
    ./ble_lib/uart/: retarget.c
  group nRF_Segger_RTT
    ./segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ./soft_device/: softdevice_handler.c
target flash_s132_nrf52_2.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: s132_nrf52_2.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\experimental_ble_app_blinky_s132_pca10040;..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
software components: CMSIS:CORE 5.0.1, Device:Startup 8.35.0
